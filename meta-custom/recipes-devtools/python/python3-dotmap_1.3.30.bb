SUMMARY = "Dotmap is a C-like dot-notation access dictionary"
HOMEPAGE = "https://github.com/drfuzzster/dotmap"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=0db53f0f62afdd84d4fa95f46d274c6d"

SRC_URI[sha256sum] = "5821a7933f075fb47563417c0e92e0b7c031158b4c9a6a7e56163479b658b368"

inherit pypi setuptools3
