FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://spi.cfg"
